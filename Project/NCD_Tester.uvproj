# Keil uVision project NCD_Tester.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: BootLoader +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 uC99=1
  c define: STM32F4XX,USE_STDPERIPH_DRIVER
  c include: ..\AppLunch;..\COM;..\Datas;..\Function;..\HardwareDriver;..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\Libraries\STM32F4x7_ETH_Driver\inc;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\Task;..\ThirdParty\Fatfs\src;..\ThirdParty\lwip-1.4.1\src\include;..\ThirdParty\lwip-1.4.1\src\include\ipv4;..\ThirdParty\lwip-1.4.1\src\include\netif;..\ThirdParty\lwip-1.4.1\src\include\lwip;..\ThirdParty\lwip-1.4.1\port\STM32F4x7\FreeRTOS;..\ThirdParty\lwip-1.4.1\port\STM32F4x7;..\ThirdParty\lwip-1.4.1\User;..\ThirdParty\USB\USB_User;..\ThirdParty\USB\STM32_USB_Device_Library\Core\inc;..\ThirdParty\cJSON-master;..\UI;..\ThirdParty\USB\STM32_USB_Device_Library\Class\cdc\inc;..\ThirdParty\USB\STM32_USB_OTG_Driver\inc;..\ThirdParty\FreeRTOS\inc;..\Daos
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../AppLunch/: main.c SystemInit.c stm32f4xx_it.c
  group Drivers
    ../HardwareDriver/: Led_Driver.c LCD_Driver.c Iwdg_Driver.c SD_SPI_Driver.c Usart6_Driver.c
  group Functions
    ../Function/: IAP_Fun.c Flash_Fun.c IAPMessage_Fun.c
  group Tasks
    ../Task/: SystemStart_Task.c
  group DataS
    ../COM/: RemoteSoft_Data.c
  group Daos
    ../Daos/: AppFileDao.c RemoteSoftDao.c
  group COM
    ../COM/: Delay.c Define.h CRC16.c MyTools.c MyMem.c Md5.c
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group STM32_Lib
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_dma.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_iwdg.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_wwdg.c misc.c stm32f4xx_rcc.c
  group Fatfs
    ../ThirdParty/Fatfs/src/: diskio.c ff.c user_fatfs.c
    ../ThirdParty/Fatfs/src/option/: syscall.c
  group Doc
    ../DOC/: README.txt
